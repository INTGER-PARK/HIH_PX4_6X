## src/modules/palletrone_mob/Kconfig
```kconfig
menuconfig MODULES_PALLETRONE_MOB
	bool "palletrone_mob"
	default n
	---help---
		Enable the publish-only Palletrone momentum observer.
```
